# Keil uVision project n76e_scm.uvproj, settings and files
target scm-temp (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: SCM_TEMP +hex
  c flags: Optimize=7
  c define: FOSC_160000
  c include: .\Include;.\Common
  group Source Group 1
    ./Code/: main.c myfunction.c timer.c lcd.c mlx90614.c button_app.c flash.c
  group Startup
    ./Startup/: STARTUP.A51
